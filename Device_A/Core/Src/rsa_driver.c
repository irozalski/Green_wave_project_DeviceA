/*
 * rsa_driver.c
 *
 *  Created on: 6 lis 2024
 *      Author: Igor
 */


//#include "crypto.h"

#include "rsa_driver.h"
#include "ring_buffer.h"
#include "rsa_keys.h"
#include "random_message.h"
/////////////////////////////Random message//////////////////////
#define MESSAGE_LENGTH 16 //- 16 bytes message
uint8_t Message[MESSAGE_LENGTH];


////////////////////////////END- Random message///////////////////

uint8_t preallocated_buffer[4096]; /* buffer required for internal allocation of memory */

/******************************************************************************/
/************************** RSA 2048 Test Vector  ****************************/
/******************************************************************************/


const uint8_t PublicExponent[] =
  {
    0x01, 0x00, 0x01
  };


//TEST MODULUS Y1 i PRIVATE X1

const uint8_t Modulus[] = {
    0xf6, 0x73, 0xd0, 0xed, 0xeb, 0x7b, 0x8a, 0xe7, 0x12, 0xe6, 0x5d, 0x17,
    0x3d, 0xc1, 0xce, 0x86, 0xe5, 0x20, 0x8b, 0x15, 0xe4, 0xb9, 0x07, 0xb0,
    0x87, 0x70, 0xba, 0xce, 0x18, 0x0d, 0xe4, 0x93, 0x88, 0x95, 0x74, 0x35,
    0xda, 0xef, 0x42, 0x7d, 0x83, 0xf7, 0x3d, 0x5d, 0x33, 0xc9, 0xbe, 0xbc,
    0xe0, 0x72, 0x61, 0xef, 0xb5, 0xd2, 0x4e, 0x10, 0x4a, 0xaa, 0x25, 0xed,
    0x40, 0xf8, 0xbb, 0x4a, 0x90, 0x36, 0x7c, 0x39, 0x27, 0xd1, 0xcd, 0x20,
    0x52, 0x51, 0x68, 0x5f, 0x14, 0xab, 0xbc, 0x61, 0x4b, 0xd8, 0x57, 0xc4,
    0x02, 0xb1, 0x67, 0xfe, 0x5c, 0xd1, 0x2c, 0x8a, 0xd9, 0x69, 0x30, 0xf1,
    0x23, 0xbd, 0x01, 0xe3, 0x67, 0x2b, 0x6c, 0x2b, 0xba, 0x6e, 0x7d, 0x41,
    0x02, 0x99, 0x6b, 0xd8, 0x89, 0x23, 0x36, 0x8d, 0xea, 0x43, 0x05, 0xe5,
    0x07, 0xb1, 0x23, 0x6e, 0xbb, 0xf8, 0x1b, 0xbb, 0xde, 0x84, 0x38, 0xca,
    0xf2, 0x29, 0x89, 0xfa, 0x39, 0x85, 0x36, 0xe2, 0xde, 0xb2, 0x33, 0x61,
    0x48, 0x5d, 0x79, 0xd4, 0xc0, 0x53, 0xe3, 0x06, 0x88, 0x35, 0x43, 0xf3,
    0x06, 0xba, 0x35, 0x33, 0x40, 0x4e, 0x4e, 0x22, 0x46, 0x06, 0xde, 0x83,
    0x74, 0x16, 0xee, 0xcf, 0x75, 0xd3, 0x64, 0x8d, 0x8a, 0x8c, 0x50, 0x6f,
    0x12, 0x77, 0x36, 0xa6, 0x44, 0xb9, 0x8b, 0x4e, 0x28, 0x9c, 0x94, 0x9c,
    0xfd, 0xdd, 0x09, 0x23, 0xd6, 0x0c, 0x7c, 0x1c, 0x30, 0xe0, 0x09, 0xf7,
    0x1a, 0xa6, 0xc4, 0x95, 0x5f, 0xd0, 0x7e, 0xc3, 0x8a, 0xd1, 0x2b, 0x4e,
    0xe0, 0x95, 0x73, 0xd5, 0xd3, 0x04, 0xc7, 0x1c, 0x02, 0x5c, 0xa6, 0x18,
    0xc0, 0xc6, 0x53, 0xb8, 0x60, 0xce, 0x42, 0x28, 0xde, 0x5a, 0x49, 0x68,
    0x12, 0x00, 0xac, 0xbf, 0x2b, 0x19, 0x87, 0x33, 0x80, 0xae, 0x9c, 0x46,
    0x5b, 0xc8, 0xf2, 0x55};

const uint8_t PrivateExponent[] = {
    0x10, 0xb9, 0x15, 0x21, 0x3f, 0xcc, 0x57, 0x45, 0x8c, 0xbb, 0xc2, 0xef,
    0x53, 0xca, 0x75, 0xd8, 0x23, 0x6e, 0x0c, 0xe2, 0x04, 0x6e, 0x25, 0xbe,
    0x6d, 0xc2, 0x51, 0x7a, 0xb0, 0x99, 0x28, 0xbc, 0x76, 0x15, 0x26, 0x18,
    0x8d, 0x6d, 0x94, 0xc6, 0x6d, 0x90, 0xf6, 0x41, 0xff, 0xc4, 0x9d, 0xc3,
    0xb5, 0x3b, 0x2d, 0xb8, 0x15, 0x4f, 0x5a, 0xea, 0xb2, 0x16, 0x4f, 0x92,
    0x84, 0xc9, 0x1b, 0xf4, 0x58, 0x4a, 0xca, 0x2d, 0x1a, 0xad, 0x9a, 0xcc,
    0xa9, 0xa9, 0x4a, 0x7a, 0xc1, 0x2d, 0x52, 0x10, 0x0c, 0x14, 0x77, 0x08,
    0x1e, 0xe2, 0xa8, 0xda, 0xd2, 0xb3, 0x82, 0xe1, 0x3d, 0x15, 0x6d, 0x33,
    0xbf, 0xa8, 0x10, 0x9b, 0xbc, 0xa1, 0x6e, 0xaa, 0x9c, 0xf0, 0xe8, 0x60,
    0xe3, 0xeb, 0x43, 0x2d, 0x23, 0x49, 0x17, 0x67, 0x93, 0xd0, 0xce, 0x72,
    0x97, 0x0e, 0x07, 0x08, 0x79, 0x8a, 0xc1, 0x5e, 0xe1, 0x08, 0xde, 0x90,
    0x73, 0x4a, 0x15, 0x27, 0x5f, 0x37, 0x08, 0xbd, 0xaf, 0x43, 0x76, 0x68,
    0x3e, 0x8a, 0x05, 0xb0, 0x40, 0x3c, 0xdf, 0x44, 0x62, 0x9a, 0x40, 0xae,
    0xc4, 0x11, 0x74, 0x1d, 0x1c, 0x67, 0x5e, 0x75, 0x78, 0x89, 0x57, 0x4d,
    0xd2, 0x71, 0x18, 0xe7, 0xa7, 0xdb, 0x0b, 0x2b, 0x2a, 0x7e, 0xbb, 0xdf,
    0x72, 0x47, 0x4a, 0x72, 0x69, 0x97, 0x24, 0x37, 0x8e, 0xf9, 0x93, 0x8d,
    0x35, 0x03, 0xf5, 0xb8, 0xd4, 0xf7, 0xba, 0xce, 0x4e, 0xb6, 0x42, 0x05,
    0x87, 0x70, 0x5f, 0x84, 0x6e, 0x1c, 0x85, 0x76, 0xaa, 0x4b, 0x73, 0x75,
    0x21, 0xed, 0x6b, 0x14, 0xf3, 0xff, 0xa0, 0xf0, 0x21, 0xe0, 0x70, 0x9b,
    0x7b, 0x72, 0x97, 0xb2, 0x79, 0x42, 0xd6, 0x17, 0x6b, 0x6d, 0x98, 0x26,
    0x46, 0x0b, 0x4c, 0x1c, 0x82, 0x0c, 0xe8, 0x38, 0x42, 0xa5, 0xbf, 0x13,
    0x47, 0x02, 0x49, 0x35};



/* String of entropy */
uint8_t entropy_data[32] =
  {
    0x91, 0x20, 0x1a, 0x18, 0x9b, 0x6d, 0x1a, 0xa7,
    0x0e, 0x69, 0x57, 0x6f, 0x36, 0xb6, 0xaa, 0x88,
    0x55, 0xfd, 0x4a, 0x7f, 0x97, 0xe9, 0x72, 0x69,
    0xb6, 0x60, 0x88, 0x78, 0xe1, 0x9c, 0x8c, 0xa5
  };

uint8_t output[2048/8];
uint8_t output1[2048/8];
int32_t outputSize = 0;

int32_t status = RSA_ERR_GENERIC;

RSApubKey_stt PubKey_st;
RSAprivKey_stt PrivKey_st;

//void RSA_Driver_getMessage(){
//	Random_message_init();
//		 GenerateRandomMessage(Message, sizeof(Message));
//}

//void RSA_Pass_Message(uint8_t *msg, uint8_t length){
//	for (uint8_t i = 0; i < length; i++) {
//	        Message[i] = msg[i];
//	    }
//	Encrypt_And_Add_Same_Message(0, Message);
//}

void Encrypt_And_Add_Same_Message(uint8_t key_number, uint8_t *output_message, size_t message_size){
	const uint8_t* key_data = get_rsa_key_set(key_number);
	if (key_data != NULL) {
		PubKey_st.mExponentSize = sizeof(PublicExponent);
		PubKey_st.mModulusSize = 256;
		PubKey_st.pmExponent = (uint8_t *) PublicExponent;
		PubKey_st.pmModulus = (uint8_t *) key_data;
	}
	status = RSA_Encrypt(&PubKey_st, output_message, message_size, output);
	if (status == RSA_SUCCESS){
		buffer_add(output, sizeof(output));
	}
}

void Decrypt_RSA_Message_And_Add_It(uint8_t key_number, uint8_t *received_message){
	//const uint8_t* key_data = get_rsa_key_set(key_number);
    PrivKey_st.mExponentSize = sizeof(PrivateExponent);
    PrivKey_st.mModulusSize = 256;
    PrivKey_st.pmExponent = (uint8_t *) PrivateExponent;
    PrivKey_st.pmModulus = (uint8_t *) Modulus;

    status = RSA_Decrypt(&PrivKey_st, received_message, output, &outputSize);
    if (status == RSA_SUCCESS){
    	Encrypt_And_Add_Same_Message(0, output, 16);
    	}
}

/////////////////////////////////////////////////////////////LIB FUNCTIONS///////////////////////////

int32_t RSA_Encrypt(RSApubKey_stt *P_pPubKey,
                    const uint8_t *P_pInputMessage,
                    int32_t P_InputSize,
                    uint8_t *P_pOutput)
{
  int32_t status = RNG_SUCCESS ;
  RNGstate_stt RNGstate;
  RNGinitInput_stt RNGinit_st;
  RNGinit_st.pmEntropyData = entropy_data;
  RNGinit_st.mEntropyDataSize = sizeof(entropy_data);
  RNGinit_st.mPersDataSize = 0;
  RNGinit_st.mNonceSize = 0;

  status = RNGinit(&RNGinit_st, &RNGstate);
  if (status == RNG_SUCCESS)
  {
    RSAinOut_stt inOut_st;
    membuf_stt mb;

    mb.mSize = sizeof(preallocated_buffer);
    mb.mUsed = 0;
    mb.pmBuf = preallocated_buffer;

    /* Fill the RSAinOut_stt */
    inOut_st.pmInput = P_pInputMessage;
    inOut_st.mInputSize = P_InputSize;
    inOut_st.pmOutput = P_pOutput;

    /* Encrypt the message, this function will write sizeof(modulus) data */
    status = RSA_PKCS1v15_Encrypt(P_pPubKey, &inOut_st, &RNGstate, &mb);
  }
  return(status);
}

/**
  * @brief  RSA Decryption with PKCS#1v1.5
  * @param  P_pPrivKey The RSA private key structure, already initialized
  * @param  P_pInputMessage Input Message to be signed
  * @param  P_MessageSize Size of input message
  * @param  P_pOutput Pointer to output buffer
  * @retval error status: can be RSA_SUCCESS if success or RSA_ERR_GENERIC in case of fail
*/
int32_t RSA_Decrypt(RSAprivKey_stt * P_pPrivKey,
                    const uint8_t * P_pInputMessage,
                    uint8_t *P_pOutput,
                    int32_t *P_OutputSize)
{
  int32_t status = RSA_SUCCESS ;
  RSAinOut_stt inOut_st;
  membuf_stt mb;

  mb.mSize = sizeof(preallocated_buffer);
  mb.mUsed = 0;
  mb.pmBuf = preallocated_buffer;

  /* Fill the RSAinOut_stt */
  inOut_st.pmInput = P_pInputMessage;
  inOut_st.mInputSize = P_pPrivKey->mModulusSize;
  inOut_st.pmOutput = P_pOutput;

  /* Encrypt the message, this function will write sizeof(modulus) data */
  status = RSA_PKCS1v15_Decrypt(P_pPrivKey, &inOut_st, P_OutputSize, &mb);
  return(status);
}




/**
  * @brief  Compares two buffers.
  * @param  pBuffer, pBuffer1: buffers to be compared.
  * @param  BufferLength: buffer's length
  * @retval PASSED: pBuffer identical to pBuffer1
  *         FAILED: pBuffer differs from pBuffer1
  */
TestStatus Buffercmp(const uint8_t* pBuffer, uint8_t* pBuffer1, uint16_t BufferLength)
{
  while (BufferLength--)
  {
    if (*pBuffer != *pBuffer1)
    {
      return FAILED;
    }

    pBuffer++;
    pBuffer1++;
  }

  return PASSED;
}

/**
  * @brief  System Clock Configuration
  *         The system Clock is configured as follow :
  *            System Clock source            = PLL (HSI)
  *            SYSCLK(Hz)                     = 84000000
  *            HCLK(Hz)                       = 84000000
  *            AHB Prescaler                  = 1
  *            APB1 Prescaler                 = 2
  *            APB2 Prescaler                 = 1
  *            HSI Frequency(Hz)              = 16000000
  *            PLL_M                          = 16
  *            PLL_N                          = 336
  *            PLL_P                          = 4
  *            PLL_Q                          = 7
  *            VDD(V)                         = 3.3
  *            Main regulator output voltage  = Scale2 mode
  *            Flash Latency(WS)              = 2
  * @param  None
  * @retval None
  */
